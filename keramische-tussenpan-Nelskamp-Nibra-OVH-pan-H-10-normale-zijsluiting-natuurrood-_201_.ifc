Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 38d9bdb5-1088-4ef8-9a24-0bea92321fea.ifc
Time: 2025-03-12T10:29:55
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcBuildingElementProxy, keramische tussenpan Nelskamp - Nibra OVH pan H-10 normale zijsluiting natuurrood (201)
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAH_yLgABAAAAeYEAAAVWkAAAhlIAAKnkAABekwAAVJsAAAAA; Hyperlink: https://bcb-online.nl/?WUID=AgAAAH_yLgABAAAAeYEAAAVWkAAAhlIAAKnkAABekwAAVJsAAAAA; werkende lengte: 380 mm; serie: Nibra OVH pan H-10; uitvoering: normale zijsluiting; gewicht per m²: 44,44 kg/m²; soortelijke warmte: 840 j/kg·k; KOMO productcertificaat: True; NL-SfB tabel 3: g9; vorstbestendig: True; werkende breedte: 250 mm; KOMO attest: True; gewicht per st: 4,4 kg/st; merk: Nelskamp; STABU2: 33.41.10; golfhoogte: 75 mm; lengte: 488 mm; hoogte: 74 mm; kleur: natuurrood (201); breedte: 299 mm; eenheid: st; dikte: 10 mm
